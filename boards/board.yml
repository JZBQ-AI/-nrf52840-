## boards/board.yml
```yaml
board:
  name: nrf52840wtkj
  full_name: WTKJ nrf52840 custom board
  vendor: wtkj
  socs:
    - name: nrf52840
```
